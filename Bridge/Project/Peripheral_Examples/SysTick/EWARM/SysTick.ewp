# IAR project SysTick.ewp, settings and files
configuration SysTick (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: ..\; ..\usb_lib\cdc; ..\usb_lib\core; ..\usb_lib\otg; ..\usb_conf; ..\cmsis_lib\include; ..\cmsis_boot; ..\..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F4-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SysTick.srec
  ILINK.IlinkOutputFile: SysTick.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
    ../: system_stm32f4xx.c
  group STM32F4-Discovery
    ../cmsis_lib/source/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_can.c
    ../usb_conf/: usb_bsp.c usbd_desc.c usbd_usr.c
    ../usb_lib/otg/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../usb_lib/cdc/: usbd_cdc_core.c usbd_cdc_vcp.c
    ../usb_lib/core/: usbd_core.c usbd_ioreq.c usbd_req.c
  group User
    ../: BRIDGE_Config.c BridgeCAN_Lib.c BridgeCOM_Lib.c main.c stm32f4xx_it.c
